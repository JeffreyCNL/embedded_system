<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\traffic_light_interrupt.ewp</path>
    </project>
    <batchBuild />
</workspace>
