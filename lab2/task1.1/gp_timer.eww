<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\gp_timer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\task1.2\timer_traffic_light.ewp</path>
    </project>
    <batchBuild />
</workspace>
