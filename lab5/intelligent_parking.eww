<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\intelligent_parking.ewp</path>
    </project>
    <batchBuild />
</workspace>
